<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>stage0</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>'localhost'</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>8000</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>Purpose: Display bytes recevied from TCP Server
Host: 'localhost'
Port: 8000</value></param>
<param><key>note</key><value>Transmission Stage 0</value></param>
</block>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
</flow_graph>
