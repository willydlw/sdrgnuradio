<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tx_gmsk</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>300e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_length</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>8e6</value></param>
</block>
<block>
<key>blks2_packet_encoder</key>
<param><key>id</key><value>blks2_packet_encoder_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>bits_per_symbol</key><value>1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>pad_for_usrp</key><value>False</value></param>
<param><key>payload_length</key><value>payload_length</value></param>
<param><key>preamble</key><value></value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/diane/repos/sdrgnuradio/test_data/text/test0123.txt</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_gmsk_mod</key>
<param><key>id</key><value>digital_gmsk_mod_0</value></param>
<param><key>bt</key><value>0.7</value></param>
<param><key>samples_per_symbol</key><value>8</value></param>
</block>
<block>
<key>limesdr_sink</key>
<param><key>id</key><value>limesdr_sink_0</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>analog_filter_ch0</key><value>1</value></param>
<param><key>cmix_mode_ch0</key><value>0</value></param>
<param><key>calibr_bandw_ch0</key><value>10e6</value></param>
<param><key>calibration_ch0</key><value>0</value></param>
<param><key>digital_bandw_ch0</key><value>0</value></param>
<param><key>digital_filter_ch0</key><value>0</value></param>
<param><key>gain_dB_ch0</key><value>30</value></param>
<param><key>pa_path_ch0</key><value>1</value></param>
<param><key>pa_path_mini</key><value>1</value></param>
<param><key>analog_filter_ch1</key><value>1</value></param>
<param><key>cmix_mode_ch1</key><value>0</value></param>
<param><key>calibr_bandw_ch1</key><value>10e6</value></param>
<param><key>calibration_ch1</key><value>0</value></param>
<param><key>digital_bandw_ch1</key><value>0</value></param>
<param><key>digital_filter_ch1</key><value>0</value></param>
<param><key>gain_dB_ch1</key><value>30</value></param>
<param><key>pa_path_ch1</key><value>1</value></param>
<param><key>chip_mode</key><value>1</value></param>
<param><key>serial</key><value>0009072C02891C20</value></param>
<param><key>device_type</key><value>2</value></param>
<param><key>file_switch</key><value>0</value></param>
<param><key>oversample</key><value>0</value></param>
<param><key>rf_freq</key><value>center_freq</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab_0@0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>gui_hint</key><value>tab_0@1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab_0</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
<param><key>label0</key><value>Multiplied Freq</value></param>
<param><key>label1</key><value>Multiplied Time</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<connection><source_block_id>blks2_packet_encoder_0</source_block_id><sink_block_id>digital_gmsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blks2_packet_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>limesdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_mod_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
