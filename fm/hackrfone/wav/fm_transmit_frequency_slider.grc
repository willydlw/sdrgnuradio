<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>transmit_wav</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>comment</key><value>Slider allows user to select broadcast
frequency</value></param>
<param><key>value</key><value>99.5e6</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>87.7e6</value></param>
<param><key>step</key><value>200e3</value></param>
<param><key>stop</key><value>107.7e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hackrf_samp_rate</value></param>
<param><key>comment</key><value>Lowest possible sample rate for HackRF One.
Change if desired.</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>wav_file_sample_rate</value></param>
<param><key>value</key><value>22050</value></param>
</block>
<block>
<key>analog_wfm_tx</key>
<param><key>id</key><value>analog_wfm_tx_0</value></param>
<param><key>audio_rate</key><value>wav_file_sample_rate*4</value></param>
<param><key>comment</key><value>Settting audio and quadrature rate to 4 times 
the wav file sample rate will produce a clearer
sound without lowering the volume</value></param>
<param><key>max_dev</key><value>75e3</value></param>
<param><key>fh</key><value>-1.0</value></param>
<param><key>quad_rate</key><value>wav_file_sample_rate*4</value></param>
<param><key>tau</key><value>25e-6</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>22050</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/diane/repos/sdrgnuradio/test_data/wav/500103_At_Aunt_Sarahs.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>Enable Audio Sink, Disable WBFM Transmit to
play the wav file on your computer.

Disable Audio Sink, enable WBFM transmit for
transmission via osmocom sink.</value></param>
<param><key>note</key><value>Operation</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>wav file sample rate property is 22050 Hz</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>hackrf_samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>comment</key><value>22050 Hz x 90 = 1,984,500 Hz

Tutorial video says this is close enough to the 
2 MHz rate of HackRF.

Interpolation 40,000  Decimation 441 matches
2MHz</value></param>
<param><key>decim</key><value>441</value></param>
<param><key>interp</key><value>40000</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>analog_wfm_tx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>analog_wfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
