<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>Diane Williams</value></param>
<param><key>description</key><value>View FM Band</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff_frequency</value></param>
<param><key>comment</key><value>FM stations have a 75 kHz maximum deviation
from the center frequency.</value></param>
<param><key>value</key><value>75e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hackrf_sample_rate</value></param>
<param><key>comment</key><value>No specific reason for this sample rate, but if
you change it or the audio sink rate, the 
decimation and interpolation values need to
be changed accordingly.</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>low_pass_decimation</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>resampler_decimation</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>resampler_interpolation</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>transition_width</value></param>
<param><key>comment</key><value>How sharply unneeded signals are filtered out.

FM has a 25 kHz guard band, so this is a good 
width value for FM radio.</value></param>
<param><key>value</key><value>25e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tuning_frequency</value></param>
<param><key>comment</key><value>103.5 MHz was chosen for this example because it
is a local FM station that can be received clearly
where I am testing.</value></param>
<param><key>value</key><value>1035e5</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>10</value></param>
<param><key>comment</key><value>Quadrature rate should be the same as the 
connected rational resampler output sample 
rate.

Decimate the input sample rate so that the
output rate matches the connected audio sink's
sample rate.</value></param>
<param><key>quad_rate</key><value>int(hackrf_sample_rate/low_pass_decimation/resampler_decimation*resampler_interpolation)</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>comment</key><value>Sample rate based on PC's audio hardware</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>length</key><value>1024</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>cc</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>comment</key><value>sample rate should match the osmocom source
sample rate, as they are directly connected.

Decimation will reduce the output sample rate.

Example: 
input sample rate / decimation = output sample rate

4 MHz / 20 = 200 kHz</value></param>
<param><key>cutoff_freq</key><value>cutoff_frequency</value></param>
<param><key>decim</key><value>low_pass_decimation</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>hackrf_sample_rate</value></param>
<param><key>width</key><value>transition_width</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>comment</key><value>Channel 0 Frequency setting tells the device which
radio channel to tune to.

RF Gain default setting is 10, but recommendation
is to change this to 0. Not necessary to have turned
on.</value></param>
<param><key>note</key><value>osomon source - HackRF One</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>comment</key><value>Filters out the direct current from the power
supply to the HackRF One, which can interfere
with the device.

With no DC blocker present in the flowgraph,
there will be a peak in the flow graph center,
which can be misinterpreted as a signal.

The DC blocker default was 32, changed to
1024 to match the default size of the FFT in
the QT Gui Sink.</value></param>
<param><key>note</key><value>DC Blocker</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>tuning_frequency</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>hackrf_sample_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>bandwidth</value></param>
<param><key>fc</key><value>tuning_frequency</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"Filtered Signal"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>bandwidth</value></param>
<param><key>fc</key><value>tuning_frequency</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>comment</key><value>Update rate indicates the amount of times per
second the graph updates.

Show RF Frequency set to Yes.</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"Source Signal"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>rate</key><value>5</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>comment</key><value>Input signal is divided by decimation and then
multiplied by interpolation.

200 kHz / 5 * 12 = 480 kHz output rate</value></param>
<param><key>decim</key><value>resampler_decimation</value></param>
<param><key>interp</key><value>resampler_interpolation</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
